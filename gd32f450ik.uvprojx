# Keil uVision project gd32f450ik.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F450IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, GD32F450, __RTTHREAD__
  c include: rt-thread\components\finsh;rt-thread\libcpu\arm\common;rt-thread\include;libraries\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\compilers\common\include;.;board;libraries\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\compilers\common\extension;libraries\gd32_drivers;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;applications;libraries\GD32F4xx_Firmware_Library\CMSIS;rt-thread\components\libc\compilers\common\extension\fcntl\octal
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
    libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_usart.c
    libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
software components: CMSIS:CORE 5.6.0
