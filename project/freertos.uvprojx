# Keil uVision project freertos.uvprojx, settings and files
target freertos (ARM-ADS)
  output: freertos
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: GD32F450,USE_STDPERIPH_DRIVER
  c include: .eide\deps;..\application;..\board;..\GD32F4xx_Firmware_Library\CMSIS;..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\freertos\include;..\freertos\portable\GCC\ARM_CM4F;..\driver
  asm define: GD32F450,USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT1: RAM 0x08000000 size 0x300000
  memory RVCT6: RAM 0x20000000 size 0x30000
  group kernel
    ../freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/portable/GCC/ARM_CM4F/: port.c
    ../freertos/portable/MemMang/: heap_4.c
  group hal
    ../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group driver
    ../driver/: gd32f4xx_enet_eval.c
  group board
    ../board/: gd32f450i_eval.c gd32f4xx_it.c systick.c
  group application
    ../application/: io.c main.c
